# Keil uVision project Wifiprogram.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Wifiprogram
  c flags: Optim=1 v6Lang=3 v6LangP=3
  c define: rvmdk PART_TM4C123GH6PM
  c misc: --c99
  c include: ..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Source Group 1
    ./: cmd.c cmd.h DelayTimer.c DelayTimer.h main.c main.h startup_rvmdk.S Hidden.h
    ../../../driverlib/rvmdk/: driverlib.lib
    ../../../utils/: uartstdio.c cmdline.c
